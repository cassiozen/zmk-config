## config/boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

config ZMK_KEYBOARD_NAME
    default "macropad"

config ZMK_ENCODER
   default y

endif
```
